# IAR project I2C_Wakeup_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M051Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\M051-LB_004\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Wakeup_Master.bin
  ILINK.IlinkOutputFile: I2C_Wakeup_Master.out
  ILINK.IlinkIcfFile: M051Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c
  group User
    ../: main.c

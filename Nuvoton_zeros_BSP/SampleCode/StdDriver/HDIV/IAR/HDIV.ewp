# IAR project HDIV.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M051Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: HDIV.bin
  ILINK.IlinkOutputFile: HDIV.out
  ILINK.IlinkIcfFile: M051Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group Source Files
    ../: main.c

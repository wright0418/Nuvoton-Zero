# IAR project TIMER_PowerDown.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M051Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_PowerDown.bin
  ILINK.IlinkOutputFile: TIMER_PowerDown.out
  ILINK.IlinkIcfFile: TIMER_PowerDown.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    ../../../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
